options:
  parameters:
    generate_options: qt_gui
    id: try2
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: center_freq
  id: variable_qtgui_range
  parameters:
    label: Center frequency
    outputmsgname: value
    showports: 'False'
    start: '87500000'
    step: '50000'
    stop: '900000000'
    value: '93400000'
  states: {}
- name: freq_1
  id: variable
  parameters:
    value: 93.4e6
  states: {}
- name: freq_2
  id: variable
  parameters:
    value: 94.4e6
  states: {}
- name: if_gain
  id: variable_qtgui_range
  parameters:
    label: if_gain
    outputmsgname: value
    showports: 'False'
    start: '0'
    step: '1'
    stop: '50'
    value: '1'
  states: {}
- name: if_samp_rate
  id: variable
  parameters:
    value: '1024000'
  states: {}
- name: quad_rate
  id: variable
  parameters:
    value: '256000'
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    label: rf gain
    outputmsgname: value
    showports: 'False'
    start: '0'
    step: '1'
    stop: '50'
    value: '0'
  states: {}
- name: rf_samp_rate
  id: variable
  parameters:
    value: '10240000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '256000'
  states: {}
- name: analog_wfm_tx_0_0
  id: analog_wfm_tx
  parameters:
    audio_rate: samp_rate
    fh: '-1.0'
    max_dev: 75e3
    quad_rate: quad_rate
    tau: '75e-6'
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /home/owen/Documents/radio/DAB-FM-HackRF-Transmit/linux/src/stream2.fifo
    repeat: 'True'
    type: short
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.000030'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_2_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '32768'
    type: complex
  states: {}
- name: blocks_short_to_float_0_0
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: osmosdr_sink_0_0
  id: osmosdr_sink
  parameters:
    args: hackrf=0000000000000000874461dc2c53b057
    bb_gain0: '20'
    freq0: center_freq
    gain0: rf_gain
    if_gain0: if_gain
    sample_rate: rf_samp_rate
    sync: none
    type: fc32
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '4'
    taps: ''
    type: ccc
  states: {state: disabled}
- name: rational_resampler_xxx_2_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '4'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_3_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '8'
    taps: ''
    type: fff
  states: {}

connections:
- [analog_wfm_tx_0_0, '0', rational_resampler_xxx_0_0, '0']
- [analog_wfm_tx_0_0, '0', rational_resampler_xxx_2_0, '0']
- [blocks_file_source_0_0, '0', blocks_short_to_float_0_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', rational_resampler_xxx_3_0, '0']
- [blocks_multiply_const_vxx_2_0, '0', osmosdr_sink_0_0, '0']
- [blocks_short_to_float_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [rational_resampler_xxx_0_0, '0', rational_resampler_xxx_2_0, '0']
- [rational_resampler_xxx_2_0, '0', blocks_multiply_const_vxx_2_0, '0']
- [rational_resampler_xxx_3_0, '0', analog_wfm_tx_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
